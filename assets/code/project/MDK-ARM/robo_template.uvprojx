# Keil uVision project robo_template.uvprojx, settings and files
target gimbal (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: robo_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,DEBUG_MODE,USE_DBUS
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..;..\Libraries\Offboard
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/AHRS
    ../Libraries/AHRS/: AHRS.cpp MahonyAHRS.cpp AHRS.h MahonyAHRS.h module.json
  group Libraries/CanDevice
    ../Libraries/CanDevice/: CanDevice.cpp CanDevice.h module.json
  group Libraries/DataStructure/Queue
    ../Libraries/DataStructure/Queue/: Queue.h
    ../Libraries/DataStructure/: module.json
  group Libraries/Error
    ../Libraries/Error/: Error.cpp Error.h module.json
  group Libraries/Flash
    ../Libraries/Flash/: Flash.cpp Flash.h module.json
  group Libraries/Helper
    ../Libraries/Helper/: Helper.cpp Helper.h module.json
  group Libraries/InertialSensor
    ../Libraries/InertialSensor/: InertialSensor.cpp InertialSensor_BMI088.cpp InertialSensor_Backend.cpp InertialSensor.h InertialSensor_Backend.h InertialSensor_BMI088.h module.json
  group Libraries/Math
    ../Libraries/Math/: AdvancedAdd.h BinaryOperations.h CommonMath.h EulerAngle.h Filters.h Matrix2.h Matrix3.h Quaternion.h RateLimiter.h Vector2.h Vector3.h AdvancedAdd.cpp Filters.cpp module.json
  group Libraries/Motor
    ../Libraries/Motor/: Motor.cpp Motor_Backend.cpp Motor.h Motor_Backend.h Motor_Data.h Motor_RM.cpp Motor_RM.h Motor_DM.cpp Motor_DM.h Motor_M15.cpp Motor_M15.h Motor_MC.cpp Motor_MC.h Motor_MG.cpp Motor_MG.h module.json
  group Libraries/Offboard
    ../Libraries/Offboard/: OffboardLink.h MessageBase.h module.json
  group Libraries/Offboard/Msgs
    ../Libraries/Offboard/msgs/: Buff.h BulletRemaining.h ChassisVelCommand.h ChassisVelYawRateCommand.h GameState.h GimbalConstantAimShootCommand.h IMUData.h MinipcHeartbeat.h PowerHeatData.h RefereeWarning.h ReferenceDataMini.h RobotAroundInformation.h RobotHurt.h RobotsHealth.h RobotStatus.h ShootData.h
  group Libraries/Offboard/queue_for_mcu
    ../Libraries/Offboard/queue_for_mcu/: queue.cpp queue.h
  group Libraries/PID
    ../Libraries/PID/: PID_Controller.cpp PID_Controller.h module.json
  group Libraries/RCProtocol
    ../Libraries/RCProtocol/: RCProtocol.cpp RCProtocol_Backend.cpp RCProtocol_DBUS.cpp RCProtocol_CAN.cpp RCProtocol.h RCProtocol_Backend.h RCProtocol_CAN.h RCProtocol_DBUS.h RCProtocol_IBUS.cpp RCProtocol_IBUS.h module.json
  group Libraries/RefereeSystem
    ../Libraries/RefereeSystem/: RefereeSystem_Data.cpp RefereeSystem_Data.h module.json
  group Libraries/Scheduler
    ../Libraries/Scheduler/: Task.cpp Scheduler.cpp Scheduler.h Scheduler_Common.cpp Scheduler_Common.h Task.h module.json
  group Libraries/UART
    ../Libraries/UART/: UARTDriver.cpp UARTDriver.h module.json
  group Libraries/Param
    ../Libraries/Param/: module.json ParamBase.h
  group Modules/AttitudeSolutionTask
    ../Modules/AttitudeSolutionTask/: AttitudeSolutionTask.cpp AttitudeSolutionTask.h module.json
  group Modules/CanTask
    ../Modules/CanTask/: CANSendTask.cpp CANSendTask.h CANSyncTask.cpp CANSyncTask.h module.json
  group Modules/MotorTask
    ../Modules/MotorTask/: Motor_DM_Task.cpp Motor_DM_Task.h Motor_M15_Task.cpp Motor_M15_Task.h Motor_MC_Tasks.cpp Motor_MC_Tasks.h Motor_MG_Tasks.cpp Motor_MG_Tasks.h Motor_RM_Tasks.cpp Motor_RM_Tasks.h module.json
  group Modules/PIDTask
    ../Modules/PIDTask/: PIDControlTask.cpp PIDControlTask.h module.json
  group Modules/RoboBase
    ../Modules/RoboBase/: ControlBase.h Task_RoboBase.h RoboBase.h module.json
  group Vehicle/Sentry_Gimbal
    ../Vehicle/Sentry_Gimbal/: vehicle.json
  group Vehicle/Sentry_Gimbal/Robot
    ../Vehicle/Sentry_Gimbal/Robot/: Robot.cpp Robot.h Params.cpp Params.h Task_Robot.h
  group Vehicle/Sentry_Gimbal/Basics
    ../Vehicle/Sentry_Gimbal/Basics/: LEDControlTask.cpp LEDControlTask.h SongPlayerTask.cpp SongPlayerTask.h SoundManagerTask.cpp SoundManagerTask.h
  group Vehicle/Sentry_Gimbal/Control
    ../Vehicle/Sentry_Gimbal/Control/: ComputerVisionControlTask.cpp ComputerVisionControlTask.h GimbalCanControlTask.cpp GimbalCanControlTask.h
  group Vehicle/Sentry_Gimbal/Gimbal
    ../Vehicle/Sentry_Gimbal/Gimbal/: GimbalControlTask.cpp GimbalControlTask.h
  group Vehicle/Sentry_Gimbal/Ammo
    ../Vehicle/Sentry_Gimbal/Ammo/: AmmoControlTask.cpp AmmoControlTask.h
  group Vehicle/Sentry_Chassis
    ../Vehicle/Sentry_Chassis/: vehicle.json
target chassis (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: robo_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,DEBUG_MODE,GUARD_CHASSIS,USE_IBUS,GAME,GOGOGO
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group added to the first target's files
    ../Core/Src/: main.cpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
